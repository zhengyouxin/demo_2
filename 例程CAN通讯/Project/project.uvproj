# Keil uVision project project.uvproj, settings and files
target STM32F407 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F417VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: project +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40XX
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\User;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: stm32f4xx_assert.c stm32f4xx_it.c main.c CAN.C NVIC.C LED.C
  group MDK-ARM
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_crc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c misc.c stm32f4xx_can.c stm32f4xx_flash.c
  group CMSIS
    ../User/: system_stm32f4xx.c
target CpuRAM (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: output +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,VECT_TAB_SRAM,STM32F40_41xxx
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User\bsp_stm32f4xx\inc;..\..\User\bsp_stm32f4xx;..\..\User
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
